# IAR project STM32F407xxxProject.ewp, settings and files
configuration STM32F407xxxProject (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; HSE_VALUE=8000000; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_USED; __ICCARM__; __IASMARM__
  ICCARM.CCDiagSuppress: Pe177,Pa082,Pa182
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Include; J:\STM32_MCU\STM32F407\STM32F407xxProject\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; J:\STM32_MCU\STM32F407\STM32F407xxProject\Drivers\STM32F4xx_HAL_Driver\Inc; J:\STM32_MCU\STM32F407\STM32F407xxProject\Drivers\STM32F4xx_HAL_Driver\Src; J:\STM32_MCU\STM32F407\STM32F407xxProject\STM32F4xx; J:\STM32_MCU\STM32F407\STM32F407xxProject\STARTUP\EWARM; J:\STM32_MCU\STM32F407\STM32F407xxProject\Complier; J:\STM32_MCU\STM32F407\STM32F407xxProject\Doc; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\AD5593; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\APP; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\AT24Cxx; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\CRC; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\Delay; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\DHT11; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\DS18B20; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\GPIO; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\I2C; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\IWDG; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\OneWire; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\PCF8563; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\Random; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\SysTick; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\USART; J:\STM32_MCU\STM32F407\STM32F407xxProject\Application\WM8510
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Main.hex
  postbuild: "$TOOLKIT_DIR$\bin\ielftool.exe" --bin --verbose  "$TARGET_PATH$" "$TARGET_BPATH$.bin"
  ILINK.IlinkOutputFile: Main.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/AD5593
    ../Application/AD5593/: ad5593_cfg.c ad5593_cfg.h ad5593_lib.c ad5593_lib.h ad5593_task.c ad5593_task.h
  group Application/APP
    ../Application/APP/: main.c main.h
  group Application/AT24Cxx
    ../Application/AT24Cxx/: at24cxx_cfg.c at24cxx_cfg.h at24cxx_lib.c at24cxx_lib.h at24cxx_task.c at24cxx_task.h
  group Application/CRC
    ../Application/CRC/: crc_cfg.c crc_cfg.h crc_lib.c crc_lib.h crc_task.c crc_task.h
  group Application/Delay
    ../Application/Delay/: delay_cfg.c delay_cfg.h delay_lib.c delay_lib.h delay_task.c delay_task.h
  group Application/DHT11
    ../Application/DHT11/: dht11_cfg.c dht11_cfg.h dht11_lib.c dht11_lib.h dht11_task.c dht11_task.h
  group Application/DS18B20
    ../Application/DS18B20/: ds18b20_cfg.c ds18b20_cfg.h ds18b20_lib.c ds18b20_lib.h ds18b20_task.c ds18b20_task.h
  group Application/GPIO
    ../Application/GPIO/: gpio_cfg.c gpio_cfg.h gpio_lib.c gpio_lib.h gpio_task.c gpio_task.h
  group Application/I2C
    ../Application/I2C/: i2c_cfg.c i2c_cfg.h i2c_lib.c i2c_lib.h i2c_task.c i2c_task.h
  group Application/IWDG
    ../Application/IWDG/: iwdg_cfg.c iwdg_cfg.h iwdg_lib.c iwdg_lib.h iwdg_task.c iwdg_task.h
  group Application/OneWire
    ../Application/OneWire/: one_wire_cfg.c one_wire_cfg.h one_wire_lib.c one_wire_lib.h one_wire_task.c one_wire_task.h
  group Application/PCF8563
    ../Application/PCF8563/: pcf8563_cfg.c pcf8563_cfg.h pcf8563_lib.c pcf8563_lib.h pcf8563_task.c pcf8563_task.h
  group Application/Random
    ../Application/Random/: random_cfg.c random_cfg.h random_lib.c random_lib.h random_task.c random_task.h
  group Application/SysTick
    ../Application/SysTick/: systick_cfg.c systick_cfg.h systick_lib.c systick_lib.h systick_task.c systick_task.h
  group Application/USART
    ../Application/USART/: usart_cfg.c usart_cfg.h usart_lib.h usart_task.c usart_task.h
  group Application/WM8510
    ../Application/WM8510/: wm8510_cfg.c wm8510_cfg.h wm8510_lib.c wm8510_lib.h wm8510_task.c wm8510_task.h
  group Complier
    ../Complier/: complier_cfg.c complier_cfg.h complier_lib.c complier_lib.h
  group Doc
    ../Doc/: ReadMe.txt
  group Drivers/CMSIS
    ../STM32F4xx/: system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_utils.h
  group STARTUP/EWARM
    ../STARTUP/EWARM/: startup_stm32f407xx.s
  group STM32F4xx
    ../STM32F4xx/: stm32_assert.h stm32_cfg.c stm32_cfg.h stm32f407xx.h stm32f4xx.h stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_ll.h
